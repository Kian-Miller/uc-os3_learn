# Keil uVision project UC-OS3_Learn.uvprojx, settings and files
target UC-OS3_LEARN (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UCOS3_learn +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\BSP\led;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M4\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\User\BSP\key;..\..\User\BSP\oled;..\..\User\BSP\flash;..\..\User\BSP\W25QXX;..\..\User\BSP\spi;..\..\User\module;..\..\User\BSP\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: stm32f4xx_it.c
  group APP
    ../../User/APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/: bsp.c bsp.h
    ../../User/BSP/usart/: bsp_debug_usart.c
    ../../User/BSP/key/: bsp_key.c
    ../../User/BSP/oled/: bsp_i2c.c bsp_oled.c
    ../../User/BSP/flash/: bsp_stmflash.c
  group uC/CPU
    ../../User/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../User/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../User/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../User/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../User/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../User/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group DOC
    ../../: README.md
